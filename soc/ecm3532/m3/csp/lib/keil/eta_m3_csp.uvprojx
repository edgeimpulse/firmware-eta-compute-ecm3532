# Keil uVision project eta_m3_csp.uvprojx, settings and files
target eta_m3_csp (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ECM3532 EtaCompute
  pack: EtaCompute.ECM35xx_DFP.1.0.34
  cpu: IRAM(0x10000000,0x00020000) IROM(0x01000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: eta_m3_csp (library)
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: ..\..\inc;..\..\..\reg\inc;..\..\..\..\common\csp\inc;..\..\..\..\..\common\inc
  memory RVCT4: ROM 0x1000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x20000
  scatter file: .\Objects\eta_m3_csp.sct
  group src
    ../../src/: eta_csp.c eta_csp_adc.c eta_csp_buck.c eta_csp_dsp.c eta_csp_flash.c eta_csp_gpio.c eta_csp_hfo.c eta_csp_i2c.c eta_csp_i2s.c eta_csp_io.c eta_csp_isr.c eta_csp_lfo.c eta_csp_m3.c eta_csp_nvic.c eta_csp_pdm.c eta_csp_pwm.c eta_csp_pwr.c eta_csp_rtc.c eta_csp_socctrl.c eta_csp_spi.c eta_csp_sys_clock.c eta_csp_timer.c eta_csp_tsense.c eta_csp_uart.c eta_csp_vhfo.c
